# Keil uVision project Cavendish.uvprojx, settings and files
target M3-Simple (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Cavendish +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,TASK_HUA
  c include: ..\User;..\CMSIS;..\Lib\Base;..\Lib\inc;..\Lib\Mode;..\Lib\src;..\Startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: stm32f10x_it.c main-Default.c main-eye.c main-car.c main-car_V2.c main-laji.c main-jiaju.c main-bus.c temp.c main-hua.c
  group Base
    ../Lib/Base/: Data_Handle.c Encoder.c PWM.c Sys_Time.c uart.c ADC.c stmflash.c Base_IIC.c
  group Mode
    ../Lib/Mode/: BZZ.c key.c lcd.c mlx90614.c Steering_engine.c Ultrasonic.c Control_Mode.c MP3.c SU_03T.c dht11.c MODE_Motor_BYJ.c RFID_Read.c OLED.c RZ7899_MOT.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ../Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
